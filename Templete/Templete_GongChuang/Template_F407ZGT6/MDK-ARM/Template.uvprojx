# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Mode;../Top;../MySystem;../Hardware;../Software;../Tools;../Function;../Con_Mode;../IMU;..\AT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group MySystem
    ../MySystem/: MySystem.c MyEncoder.c MyGPIO.c MyPWM.c MyTimer.c
  group Top
    ../Top/: AllHeader.c AllHeader.h Mymain.c Mymain.h
  group Mode
    ../Mode/: Mode_G.c Mode_1.c Mode_2.c Mode_3.c Mode_4.c Mode_5.c Mode_6.c
  group Hardware
    ../Hardware/: Key.c OLED.c OLED_Data.c Serial_base.c RGB.c Encoder_Key.c TJC_LCD.c
  group SoftWare
    ../Software/: MyPID.c MyPID.h Queue.h Queue.c
  group Tools
    ../Tools/: LED_Flash.c LED_Flash.h Timer_Counter.c Timer_Counter.h
  group Function
    ../Function/: Serial_porting.c Serial_porting.h
  group IMU
    ../IMU/: ICM_42688_base.c ICM42688_Angle.c ICM42688_Mahony.c IMU.c MPU6050_Angle.c MPU6050_base.c MPU6050_Mahony.c
  group AT
    ../AT/: at24c02_manager.c bsp_at24c02.c Param_AT24C02.c ParamEdit.c
software components: CMSIS:CORE 4.3.0
